# Keil uVision project x_platform.uvprojx, settings and files
target xPlatform (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: x_platform +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\ApplicationLayer\main;..\HardwareAbstractionLayer\Interrupt;..\HardwareAbstractionLayer\Key;..\HardwareAbstractionLayer\Led;..\HardwareAbstractionLayer\Platform;..\HardwareAbstractionLayer\RTC;..\HardwareAbstractionLayer\SD;..\HardwareAbstractionLayer\Sram;..\HardwareAbstractionLayer\Timer;..\HardwareAbstractionLayer\Uart;..\HardwareAbstractionLayer\Watchdog;..\HardwareDriverLayer\DWT;..\HardwareDriverLayer\GPIO;..\HardwareDriverLayer\HardwareCore;..\HardwareDriverLayer\Interrupt;..\HardwareDriverLayer\RTC;..\HardwareDriverLayer\SD;..\HardwareDriverLayer\SPI;..\HardwareDriverLayer\Sram;..\HardwareDriverLayer\STM32F10x_FWLib\inc;..\HardwareDriverLayer\Timer;..\HardwareDriverLayer\Uart;..\HardwareDriverLayer\Watchdog;..\RuntimeEnvironment\Hal_Interface;..\RuntimeEnvironment\Service_Interface;..\RuntimeEnvironment\Env_Config;..\RuntimeEnvironment\Appl_Interface;..\ServicesLayer\Algor;..\ServicesLayer\DataStructOpt\inc;..\ServicesLayer\FATFS\src;..\ServicesLayer\FATFS\src\option;..\ServicesLayer\Lib;..\ServicesLayer\Memory;..\ServicesLayer\osal\inc;..\ServicesLayer\uCOSIII\uC-CPU;..\ServicesLayer\uCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\ServicesLayer\uCOSIII\uC-LIB;..\ServicesLayer\uCOSIII\uC-LIB\Ports;..\ServicesLayer\uCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\ServicesLayer\uCOSIII\uCOS-Config;..\ServicesLayer\uCOSIII\uCOS-III\Source;..\ServicesLayer\uCOSIII\uCOS-III\Ports;..\ServicesLayer\uCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\RuntimeEnvironment\Rte_Rtos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Appl
    ../ApplicationLayer/main/: main.c main.h
  group Rte
    ../RuntimeEnvironment/Env_Config/: rte.h rte_config.h
    ../RuntimeEnvironment/Hal_Interface/: rte_bsw_hal_if.h
    ../RuntimeEnvironment/Service_Interface/: rte_bsw_srv_if.h
    ../RuntimeEnvironment/Rte_Rtos/: rte_bsw_rtos_if.h
  group Osal
    ../ServicesLayer/osal/src/: osal.c
    ../ServicesLayer/osal/inc/: osal.h
  group DataStruct
    ../ServicesLayer/DataStructOpt/src/: srv_queue.c
    ../ServicesLayer/DataStructOpt/inc/: srv_queue.h
  group StdLib
    ../ServicesLayer/Lib/: std_lib.c std_lib.h
  group Algorithm
    ../ServicesLayer/Algor/: srv_algor.c srv_algor.h
  group uC_Cpu
    ../ServicesLayer/uCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../ServicesLayer/uCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC_Lib
    ../ServicesLayer/uCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../ServicesLayer/uCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC_Config
    ../ServicesLayer/uCOSIII/uCOS-Config/: bsp_os.c bsp_os.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
  group uC/OS
    ../ServicesLayer/uCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../ServicesLayer/uCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group Memory
    ../ServicesLayer/Memory/: srv_memory.c srv_memory.h
  group FatFs
    ../ServicesLayer/FATFS/src/: ff.c diskio.c
    ../ServicesLayer/FATFS/src/option/: cc936.c
  group Hal
    ../HardwareAbstractionLayer/Interrupt/: hal_int.c hal_int.h hal_int_pub.h
    ../HardwareAbstractionLayer/Key/: hal_key.c hal_key.h hal_key_pub.h
    ../HardwareAbstractionLayer/Led/: hal_led.c hal_led.h hal_led_pub.h
    ../HardwareAbstractionLayer/Platform/: hal.c hal.h
    ../HardwareAbstractionLayer/RTC/: hal_rtc.c hal_rtc.h hal_rtc_pub.h
    ../HardwareAbstractionLayer/SD/: hal_sd.c hal_sd.h hal_sd_pub.h
    ../HardwareAbstractionLayer/Sram/: hal_sram.c hal_sram.h hal_sram_pub.h
    ../HardwareAbstractionLayer/Timer/: hal_timer.c hal_timer.h hal_timer_pub.h
    ../HardwareAbstractionLayer/Uart/: hal_uart.c hal_uart.h hal_uart_pub.h
    ../HardwareAbstractionLayer/Watchdog/: hal_wdg.c hal_wdg.h hal_wdg_pub.h
  group Drv
    ../HardwareDriverLayer/DWT/: drv_dwt.c drv_dwt.h drv_dwt_pub.h
    ../HardwareDriverLayer/GPIO/: drv_gpio.c drv_gpio.h drv_gpio_pub.h
    ../HardwareDriverLayer/HardwareCore/: core_cm3.c core_cm3.h platforms.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
    ../HardwareDriverLayer/Interrupt/: drv_int.c drv_int.h drv_int_pub.h
    ../HardwareDriverLayer/RTC/: drv_rtc.c drv_rtc.h drv_rtc_pub.h
    ../HardwareDriverLayer/SD/: drv_sd.c drv_sd.h drv_sd_pub.h
    ../HardwareDriverLayer/SPI/: drv_spi.c drv_spi.h drv_spi_pub.h
    ../HardwareDriverLayer/Sram/: drv_sram.c drv_sram.h drv_sram_pub.h
    ../HardwareDriverLayer/Timer/: drv_timer.c drv_timer.h drv_timer_pub.h
    ../HardwareDriverLayer/Uart/: drv_uart.c drv_uart.h drv_uart_pub.h
    ../HardwareDriverLayer/Watchdog/: drv_wdg.c drv_wdg.h drv_wdg_pub.h
  group StLib
    ../HardwareDriverLayer/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../HardwareDriverLayer/STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
